## boards/shields/nrfkb/Kconfig.defconfig
```kconfig
if NRFKB

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "nRF Keyboard"

endif
```
